# Keil uVision project STM32F4xx_MDK_contiki.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MDK_contiki +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx AUTOSTART_ENABLE
  c include: ..\3APP;..\2Third_Party\FatFs_vR0.08a;..\2Third_Party\contiki-3.0\core\sys;..\2Third_Party\contiki-3.0\core;..\2Third_Party\contiki-3.0\core\lib;..\2Third_Party\contiki-3.0\cpu\arm\stm32f4xx;..\1BSP\inc;..\0Libraries\CMSIS\Include;..\0Libraries\STM32F4xx_StdPeriph_Driver\inc;..\0Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../0Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../0Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group lib
    ../0Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ../1BSP/src/: bsp.c LED.c stm32f4xx_it.c uart.c RTC.c stm324xg_eval.c stm324xg_eval_sdio_sd.c LCD12864.c tool.c
  group CPU
    ../2Third_Party/contiki-3.0/cpu/arm/stm32f4xx/: clock.c
  group APP
    ../3APP/: contiki-main.c displaytime.c FatFS.c
  group contiki
    ../2Third_Party/contiki-3.0/core/sys/: autostart.c etimer.c process.c timer.c
  group Fatfs
    ../2Third_Party/FatFs_vR0.08a/: ff.c diskio.c
    ../2Third_Party/FatFs_vR0.08a/option/: ccsbcs.c
